# Keil uVision project Remote.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Remote +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --c99
  c include: .\MyDriver;.\STM32_LIB\LIB\inc;.\User;.\STM32_LIB\CMSIS;.\USB_LIB;.\USB_HID
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c Config.h Years_Schedule.c
  group MyDriver
    ./MyDriver/: Years_LED.c board.c stm32f10x_it.c Years_SPI.c Years_Nrf24l01.c Years_Uart.c Years_USB_HID.c Years_Remote.c Years_KEY.c
  group STM32_LIB
    ./STM32_LIB/CMSIS/: startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c core_cm3.c
    ./STM32_LIB/LIB/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group USB_LIB
    ./USB_LIB/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group USB_HID
    ./USB_HID/: usb_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
